File: power.sch (KiCad schematic (older format))
At the start: 30 parts

Commit message: Various changes
Parts:
- gave numbers to parts that had none: 30
