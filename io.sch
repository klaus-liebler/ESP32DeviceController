File: io.sch (KiCad schematic (older format))
At the start: 75 parts

Commit message: Various changes
Parts:
- gave numbers to parts that had none: 71
